# Keil uVision project ProjectTemplate.uvprojx, settings and files
target FLASH (6240000::V6.24::ARMCLANG)
  device: TAE32G5800 Tai-Action
  pack: Tai-Action.TAE32G58xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x20010000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProjectTemplate +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\..\..\Drivers\TAE32G58xx_Device\Inc;..\..\..\Drivers\TAE32G58xx_Driver\Inc;..\..\..\Utilities;..\..\User\Inc;..\..\..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\FLASH\tae32g58xx_ac6_flash.sct
  group APP
    ../../../APP/: hrpwm_app.c variables_define_app.c adc_app.c gpio_app.c cmp_app.c dac_app.c user_vofa.c pid_app.c protection_app.c include_app.h variables_define_app.h iwdg_app.c tmr_app.h
    ./: tmr_app.c
  group ProjectTemplate/User
    ../../User/Src/: main.c tae32g58xx_it.c tae32g58xx_ll_msp.c utils.c state_machine.c
  group Drivers/TAE_Driver
    ../../../Drivers/TAE32G58xx_Driver/Src/: tae32g58xx_ll.c tae32g58xx_ll_cortex.c tae32g58xx_ll_rcu.c tae32g58xx_ll_gpio.c tae32g58xx_ll_uart.c tae32g58xx_ll_sysctrl.c tae32g58xx_ll_dma.c tae32g58xx_ll_eflash.c tae32g58xx_ll_tmr.c tae32g58xx_ll_iir.c tae32g58xx_ll_cordic.c tae32g58xx_ll_qei.c tae32g58xx_ll_iwdg.c tae32g58xx_ll_wwdg.c tae32g58xx_ll_i2c.c tae32g58xx_ll_spi.c tae32g58xx_ll_can.c tae32g58xx_ll_usb.c tae32g58xx_ll_xif.c tae32g58xx_ll_adc.c tae32g58xx_ll_dac.c tae32g58xx_ll_cmp.c tae32g58xx_ll_pdm.c tae32g58xx_ll_hrpwm.c
  group Drivers/TAE_Device
    ../../../Drivers/TAE32G58xx_Device/Src/: startup_tae32g58xx.c system_tae32g58xx.c
  group Utilities/Debug
    ../../../Utilities/dbg/: user_debug.c
target SRAM (6140000::V6.14::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ProjectTemplate +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Drivers\TAE32G58xx_Device\Inc;..\..\..\Drivers\TAE32G58xx_Driver\Inc;..\..\..\Utilities;..\..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\SRAM\tae32g58xx_ac6_sram.sct
software components: CMSIS:CORE 5.6.0
